# Keil uVision project finalPro.uvproj, settings and files
target LPC1700 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: finalPro
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Files
    ./: startup_LPC17xx.s GLCD_SPI_LPC1700.c LED.c system_LPC17xx.c KBD.c logo1.c logo2.c logo3.c main.c play_icon.c
  group USB
    ./: adcuser.c core_cm3.c usbcore.c usbdesc.c usbdmain.c usbhw.c usbuser.c
  group Snake
    ./: snake_food.c snake_skin.c Black_End.c Main_Logo.c
